# Keil uVision project USB_beacon.uvprojx, settings and files
target MorseGenerator (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F070F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: MorseGenerator +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070x6, USE_XTAL_8MHZzzz
  c misc: --C99
  c include: ./Inc;../../Drivers/STM32F0xx_HAL_Driver/Inc;../../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../STM32_LIBRARIES
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./Src/: startup_stm32f070xc.s
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/Main
    ./src/: command.c
    ./Src/: stm32f0xx_hal_msp.c main.c stm32f0xx_it.c audio.c morse.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Application/USB
    src/: CDC_receiver.c
    ./Src/: usbd_cdc_if.c usb_device.c usbd_conf.c usbd_desc.c
target MorseGenerator-HSE (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F070F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: MorseGeneratorHSE +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070x6, USE_XTAL_8MHZ
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
